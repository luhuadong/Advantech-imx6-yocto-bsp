DEPENDS += " qtdeclarative"
