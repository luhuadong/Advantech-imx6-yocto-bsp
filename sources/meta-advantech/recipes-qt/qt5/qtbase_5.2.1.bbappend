PACKAGECONFIG_append = " \
	alsa \
	accessibility \
	glib \
	openvg \
	fontconfig \
	sql-sqlite \
"
