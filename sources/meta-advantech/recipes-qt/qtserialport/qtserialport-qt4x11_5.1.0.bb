inherit qt4x11

require ../../../meta-openembedded/meta-oe/recipes-qt/qtserialport/qtserialport.inc

SRCREV = "22e45f0b0f956c025339d72ad53dca57ef684858"

