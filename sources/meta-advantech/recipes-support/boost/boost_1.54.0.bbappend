BOOST_LIBS += "\
	log \
	atomic \
	locale \
	"
