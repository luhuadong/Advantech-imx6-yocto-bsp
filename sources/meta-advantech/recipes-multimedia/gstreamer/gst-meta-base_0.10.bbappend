DEPENDS = "gstreamer gst-plugins-base gst-plugins-good"

