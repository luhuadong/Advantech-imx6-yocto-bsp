FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://nbench_misc.patch"
